# Keil uVision project Player.uvprojx, settings and files
target Player (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F756ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Player
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F7xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Drivers/CMSIS
    E:/Dropbox/Dropbox (Personal)/Freelance/Rebel Tech/Git Repository/RebelTechnology/Player/firmware/Source/: system_stm32f7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
  group Application/User
    ../Src/: usbd_audio_if.c stm32f7xx_hal_msp.c main.c usbh_conf.c usb_host.c stm32f7xx_it.c usb_device.c usbd_conf.c usbd_desc.c
    ../Source/: HAL_CV_IO.c HAL_Encoders.c HAL_Triggers.c
    ./: HAL_OLED.c test.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ioreq.c usbh_core.c usbh_ctlreq.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Src/: usbh_audio.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_fmc.c stm32f7xx_hal_uart.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_hcd.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_pcd.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_sai.c stm32f7xx_hal.c stm32f7xx_hal_dma.c stm32f7xx_ll_usb.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rtc.c stm32f7xx_hal_gpio.c
software components: CMSIS:CORE 4.1.0
